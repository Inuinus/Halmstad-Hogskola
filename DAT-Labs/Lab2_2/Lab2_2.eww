<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\Lab2_1\Lab2_1_1.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Lab2_2.ewp</path>
    </project>
    <batchBuild />
</workspace>
